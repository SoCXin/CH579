# Keil uVision project BLE.uvproj, settings and files
target BLE_ImageOTA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ImageOTA +hex
  c flags: v6Lang=1 v6LangP=1
  c define: DEBUG,CH57xBLE_ROM
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\LIB;..\..\..\SRC\CMSIS\Include;..\..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x24800 size 0x2000
  memory RVCT9: RAM 0x20006000 size 0x2000
  group app
    ../APP/: OTAnobackup.c OTAnobackup_main.c
  group profile
    ../Profile/: OTAprofile.c
  group drive
    ../../../SRC/Startup/: startup_ARMCM0.s
    ../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_sys.c CH57x_uart1.c CH57x_int.c CH57x_pwr.c CH57x_flash.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c
  group config
    ../../HAL/include/: config.h
