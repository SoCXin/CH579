# Keil uVision project BLE.uvprojx, settings and files
target CH57x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_mesh +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: LIGHT_2 DEBUG=1 HAL_KEY BLE_MEMHEAP_SIZE=1024*4  BLE_MAC=TRUE  BLE_SNV=0 BLE_SNV_ADDR=0x3E800+0x600
  c include: ..\..\..\..\SRC\StdPeriphDriver\inc;..\..\..\..\SRC\CMSIS\Include;..\..\..\LIB;..\..\..\HAL\include;..\..\LIB\include;..\APP\include;..\..\LIB\include\LIBC;..\..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../APP/: app.c common_trace.c als_vendor_model.c generic_onoff_model.c
  group comm
    ../../Common/: dbg.c mesh_cfg.c
  group drive
    ../../../../SRC/Startup/: startup_ARMCM0.s
    ../../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_sys.c CH57x_pwr.c CH57x_uart1.c CH57x_lcd.c CH57x_int.c
  group hal
    ../../../HAL/: MCU.c RTC.c SLEEP.c KEY.c
  group config
    ../../../HAL/include/: config.h
  group lib
    ../../../LIB/: CH57xBLE.lib
    ../../LIB/: BLE-MESH_RLY.lib
