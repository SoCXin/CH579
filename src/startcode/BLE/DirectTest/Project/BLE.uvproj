# Keil uVision project BLE.uvproj, settings and files
target BLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: BLE +hex
  c flags: v6Lang=1 v6LangP=1
  c define: DEBUG=1,BLE_DIRECT_TEST=TRUE,HAL_KEY,HAL_LED
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\LIB;..\..\..\SRC\CMSIS\Include;..\..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group app
    ../APP/: directtest.c directtest_main.c
  group drive
    ../../../SRC/Startup/: startup_ARMCM0.s
    ../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c LED.c KEY.c
  group lib
    ../../LIB/: CH57xBLE.LIB
  group config
    ../../HAL/include/: config.h
