# Keil uVision project CH57x.uvproj, settings and files
target CH57x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CH57x +hex
  c define: DEBUG=1
  c include: ..\..\..\..\SRC\CMSIS\Include;..\..\..\..\SRC\Startup;..\..\..\..\SRC\StdPeriphDriver\inc;..\..\USB_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: EXAM10.C
  group udisk_lib
    ../../USB_LIB/: CH579UFI.C CH579UFI.lib
  group peripheral
    ../../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_sys.c CH57x_usbhostBase.c CH57x_usbhostClass.c CH57x_uart1.c CH57x_pwr.c
  group startup
    ../../../../SRC/Startup/: startup_ARMCM0.s
