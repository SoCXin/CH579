# Keil uVision project TCP_Server.uvproj, settings and files
target TCP_Server (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: TCP_server +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CLK32MSYS,DEBUG
  c misc: --diag_suppress=231
  c include: ..\..\SRC\CMSIS\Include;..\LIB;..\..\SRC\StdPeriphDriver;..\..\SRC\CMSIS\Include;..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: TCP_Server.c
  group Driver
    ../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_pwr.c CH57x_gpio.c CH57x_uart1.c CH57x_sys.c CH57x_int.c
  group Startup
    ../../SRC/Startup/: startup_ARMCM0.s
  group Lib
    ../LIB/: CH57xNET.LIB
