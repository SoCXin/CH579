# Keil uVision project MQTT_Sub.uvprojx, settings and files
target MQTT_Sub (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH579M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CH579_MQTT_SUB +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=231
  c include: ..\..\..\SRC\CMSIS\Include;..\..\LIB;..\MQTT_SRC;..\..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: MQTT_Sub.c
  group Driver
    ../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c CH57x_int.c
  group Startup
    ../../../SRC/Startup/: startup_ARMCM0.s
  group Lib
    ../../LIB/: CH57xNET.LIB
  group MQTT
    ../MQTT_SRC/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
software components: CMSIS:CORE 5.2.0
