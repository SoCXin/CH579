# Keil uVision project CH57x.uvprojx, settings and files
target CH57x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CH57x +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\..\SRC\StdPeriphDriver\inc;..\..\SRC\CMSIS\Include;..\..\SRC\Startup;..\NetLib;..\MQTT;.\MQTT\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: Main.c net_config.h
  group peripheral
    ../../SRC/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_pwm.c CH57x_pwr.c CH57x_timer0.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_usbdev.c CH57x_sys.c
  group MQTT
    ./MQTT/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group startup
    ../../SRC/Startup/: startup_ARMCM0.s
  group NetLib
    ../NetLib/: eth_driver.c CH57xNET.lib
