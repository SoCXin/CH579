# Keil uVision project demo.uvprojx, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: demo +hex
  AfterMake: fromelf.exe  --bin -o  ./demo.bin  ./obj/demo.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\..\Libs\Startup;..\..\Libs\CMSIS\Include;..\..\Libs\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./: main.c
  group startup
    ../../Libs/Startup/: startup_ARMCM0.s
  group peripheral
    ../../Libs/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_sys.c CH57x_timer0.c CH57x_uart1.c CH57x_usbdev.c CH57x_usbhostBase.c CH57x_usbhostClass.c
software components: CMSIS:CORE 5.1.2
