# Keil uVision project CH57x.uvprojx, settings and files
target CH57x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CH57x +hex
  c flags: v6Lang=1 v6LangP=1
  c define: DEBUG=1
  c include: ..\..\..\..\Libs\CMSIS\Include;..\..\..\..\Libs\LIB;..\..\..\..\Libs\StdPeriphDriver\inc;..\..\..\..\Libs\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./: EXAM11.C
  group udisk_lib
    ../../../../Libs/LIB/: CH579UFI.C CH579UFI.lib
  group peripheral
    ../../../../Libs/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_sys.c CH57x_usbhostBase.c CH57x_usbhostClass.c CH57x_uart1.c CH57x_pwr.c
  group startup
    ../../../../Libs/Startup/: startup_ARMCM0.s
software components: CMSIS:CORE 5.1.1
