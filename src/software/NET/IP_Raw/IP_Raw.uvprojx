# Keil uVision project IP_Raw.uvprojx, settings and files
target IP_Raw (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: IP_RAW +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=231
  c include: ..\..\Libs\CMSIS\Include;..\..\Libs\LIB;..\..\Libs\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: IP_Raw.c
  group Driver
    ../../Libs/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c
  group Startup
    ../../Libs/Startup/: startup_ARMCM0.s
  group Lib
    ../../Libs/LIB/: CH57xNET.LIB
software components: CMSIS:CORE 5.1.1
