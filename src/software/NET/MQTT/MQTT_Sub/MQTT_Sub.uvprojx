# Keil uVision project MQTT_Sub.uvprojx, settings and files
target MQTT_Pub (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Sub +hex
  AfterMake: fromelf.exe  --bin -o  ./Sub.bin  ./obj/Sub.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=231
  c include: ..\..\..\Libs\CMSIS\Include;..\..\..\Libs\NET;..\MQTT_SRC;..\..\..\Libs\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: main.c
  group Driver
    ../../../Libs/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c
  group Startup
    ../../../Libs/Startup/: startup_ARMCM0.s
  group Lib
    ../../../Libs/NET/: CH57xNET.LIB
  group MQTT
    ../MQTT_SRC/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
software components: CMSIS:CORE 5.2.0
