# Keil uVision project TCP_Server.uvprojx, settings and files
target TCP_Server (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: TCP_server +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CLK32MSYS,DEBUG
  c misc: --diag_suppress=231
  c include: ..\..\Libs\CMSIS\Include;..\..\Libs\LIB;..\..\Libs\StdPeriphDriver;..\..\Libs\CMSIS\Include;..\..\Libs\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: TCP_Server.c
  group Driver
    ../../Libs/StdPeriphDriver/: CH57x_clk.c CH57x_pwr.c CH57x_gpio.c CH57x_uart1.c CH57x_sys.c
  group Startup
    ../../Libs/Startup/: startup_ARMCM0.s
  group Lib
    ../../Libs/LIB/: CH57xNET.LIB
software components: CMSIS:CORE 5.1.1
