# Keil uVision project BLE.uvproj, settings and files
target BLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: BLE +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\..\Libs\LIB;..\..\..\Libs\CMSIS\Include;..\..\..\Libs\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group app
    ../APP/: hidkbd.c hidkbd_main.c
  group profile
    ../Profile/: battservice.c devinfoservice.c hiddev.c hidkbdservice.c scanparamservice.c
  group drive
    ../../../Libs/Startup/: startup_ARMCM0.s
    ../../../Libs/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c
  group lib
    ../../../Libs/LIB/: CH57xBLE.LIB
  group config
    ../../HAL/include/: config.h
