# Keil uVision project OTA.uvprojx, settings and files
target BLE_ImageA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ImageA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\..\Libs\BLE;..\..\..\Libs\CMSIS\Include;..\..\..\Libs\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../APP/: Peripheral.c Peripheral_main.c
  group profile
    ../Profile/: devinfoservice.c GATTprofile.c OTAprofile.c
  group drive
    ../../../Libs/Startup/: startup_ARMCM0.s
    ../../../Libs/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c CH57x_flash.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c
  group lib
    ../../../Libs/BLE/: CH57xBLE.LIB
  group config
    ../APP/include/: config.h
target BLE_ImageB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: ImageB +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.1.2
