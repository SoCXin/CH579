# Keil uVision project BLE.uvprojx, settings and files
target CH57x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE +hex
  c flags: v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\LIB;..\..\..\SRC\CMSIS\Include;..\..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group app
    ../APP/: hidconsumer.c hidconsumer_main.c
  group profile
    ../Profile/: battservice.c devinfoservice.c hiddev.c hidconsumerservice.c scanparamservice.c
  group drive
    ../../../SRC/Startup/: startup_ARMCM0.s
    ../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c CH57x_int.c CH57x_adc.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c
  group lib
    ../../LIB/: CH57xBLE.LIB
  group config
    ../../HAL/include/: config.h
