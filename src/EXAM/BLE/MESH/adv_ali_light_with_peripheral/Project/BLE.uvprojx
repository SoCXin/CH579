# Keil uVision project BLE.uvprojx, settings and files
target CH57x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG,HAL_KEY=1
  c include: ..\APP\include;..\Profile\include;..\..\..\HAL\include;..\..\..\LIB;..\..\..\..\SRC\CMSIS\Include;..\..\..\..\SRC\StdPeriphDriver\inc;..\..\MESH_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../APP/: app.c app_vendor_model.c app_generic_onoff_model.c app_main.c app_mesh_config.c peripheral.c
    ../APP/include/: app_mesh_config.h
    ../Profile/: gattprofile.c
  group drive
    ../../../../SRC/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c
    ../../../../SRC/Startup/: startup_ARMCM0.s
  group hal
    ../../../HAL/: KEY.c MCU.c RTC.c SLEEP.c
  group lib
    ../../../LIB/: CH57xBLE.lib
    ../../MESH_LIB/: MESH_LIB.lib
  group config
    ../../../HAL/include/: config.h
